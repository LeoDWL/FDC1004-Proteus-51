# Keil uVision project LCD_Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD_Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware\src;.\Hardware\inc
  group Source Group 1
    ./: STARTUP.A51 main.c
  group Hardware
    ./Hardware/src/: LCD12864.c i2c.c delay.c FDC1004.c
